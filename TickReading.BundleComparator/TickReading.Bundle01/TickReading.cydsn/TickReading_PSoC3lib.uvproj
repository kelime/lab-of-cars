# Keil uVision project TickReading_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: TickReading_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h LCD.c LCD.h LCD_PM.c LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h ISR_Hall.c ISR_Hall.h ISR_Overflow.c ISR_Overflow.h PWM.c PWM.h PWM_PM.c Input_LED.c Input_LED.h Input_LED_aliases.h Hall_Counter.c Hall_Counter.h Hall_Counter_PM.c Clock_Hall.c Clock_Hall.h Hall_To_PSOC.c Hall_To_PSOC.h Hall_To_PSOC_aliases.h Composite_Video.c Composite_Video.h Composite_Video_aliases.h Horizontal_Sync_Line.c Horizontal_Sync_Line.h Horizontal_Sync_Line_aliases.h Vertical_Sync_Frame.c Vertical_Sync_Frame.h Vertical_Sync_Frame_aliases.h Lines_Per_Frame_Counter.c Lines_Per_Frame_Counter.h Lines_Per_Frame_Counter_PM.c ISR_50_Lines.c ISR_50_Lines.h ISR_100_Lines.c ISR_100_Lines.h Line_Timer.c Line_Timer.h Line_Timer_PM.c Camera_Comp.c Camera_Comp.h Camera_Comp_PM.c Camera_Threshold.c Camera_Threshold.h Camera_Threshold_PM.c Steering_Output.c Steering_Output.h Steering_Output_aliases.h Clock_Steering.c Clock_Steering.h PWM_Steering.c PWM_Steering.h PWM_Steering_PM.c drive_output_1.c drive_output_1.h drive_output_1_aliases.h drive_output_2.c drive_output_2.h drive_output_2_aliases.h elevator_input.c elevator_input.h elevator_input_aliases.h Elevator_Comparator.c Elevator_Comparator.h Elevator_Comparator_PM.c Elevator_Threshold.c Elevator_Threshold.h Elevator_Threshold_PM.c ISR_Elevator.c ISR_Elevator.h elevator_test.c elevator_test.h elevator_test_aliases.h Drive_Control_Reg.c Drive_Control_Reg.h elevator_input_2.c elevator_input_2.h elevator_input_2_aliases.h Elevator_Comparator_1.c Elevator_Comparator_1.h Elevator_Comparator_1_PM.c ISR_Elevator_2.c ISR_Elevator_2.h Wait_Counter.c Wait_Counter.h Wait_Counter_PM.c Wait_Clock.c Wait_Clock.h ISR_Wait.c ISR_Wait.h I2C_Pressure.c I2C_Pressure.h I2C_Pressure_BOOT.c I2C_Pressure_INT.c I2C_Pressure_PM.c Pressure_SCL.c Pressure_SCL.h Pressure_SCL_aliases.h Pressure_SDA.c Pressure_SDA.h Pressure_SDA_aliases.h Altimeter_Counter.c Altimeter_Counter.h Altimeter_Counter_PM.c Altimeter_Clock.c Altimeter_Clock.h ISR_Altimeter.c ISR_Altimeter.h Pixy_Input.c Pixy_Input.h Pixy_Input_aliases.h ISR_Pixy.c ISR_Pixy.h side_rangefinder.c side_rangefinder.h side_rangefinder_aliases.h Side_Rangefinder_Comparator.c Side_Rangefinder_Comparator.h Side_Rangefinder_Comparator_PM.c ISR_Side_Rangefinder.c ISR_Side_Rangefinder.h ADC_Side_Rangefinder.c ADC_Side_Rangefinder.h ADC_Side_Rangefinder_PM.c ADC_Side_Rangefinder_INT.c ADC_Side_Rangefinder_theACLK.c ADC_Side_Rangefinder_theACLK.h ADC_Side_Rangefinder_Ext_CP_Clk.c ADC_Side_Rangefinder_Ext_CP_Clk.h ADC_Side_Rangefinder_AMux.c ADC_Side_Rangefinder_AMux.h Wall_Threshold.c Wall_Threshold.h Wall_Threshold_PM.c
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: TickReading_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
